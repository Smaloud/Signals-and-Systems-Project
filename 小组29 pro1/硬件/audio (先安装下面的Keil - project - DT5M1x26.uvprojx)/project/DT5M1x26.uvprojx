# Keil uVision project DT5M1x26.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: DT5M1x26 DTChip
  pack: Keil.DTChip_DFP.0.1.3
  cpu: IRAM(0x03000000,0x02000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DT5M1x26 +hex
  AfterMake: fromelf --bin  .\Objects\@L.axf --output @L.bin
  AfterMake: build_hex.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\usr\inc;..\Library\CMSIS\Include;..\Library\StdPeriph_Driver\inc;..\Library\Device\ChipWise\DT5M1x26\Include;..\Library\Source;..\usr\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x3000000 size 0x2000
  group usr
    ../usr/src/: main.c DT5M1x26_it.c
  group startup
    ../Library/Source/: startup_DT5M1x26.s system_DT5M1x26.c
  group StdLib
    ../Library/StdPeriph_Driver/src/: dt5m1x26_adc.c dt5m1x26_audio.c dt5m1x26_gpio.c dt5m1x26_i2c.c dt5m1x26_pwm.c dt5m1x26_rcc.c dt5m1x26_rtc.c dt5m1x26_spi.c dt5m1x26_systick.c dt5m1x26_timer.c dt5m1x26_uart.c dt5m1x26_wdt.c dt5m1x26_aes.c dt5m1x26_cmp.c dt5m1x26_flash.c
